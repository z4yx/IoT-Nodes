# Keil uVision project IoT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IoT +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\;..\usb\inc;..\config;..\drivers\system;..\drivers\actuators;..\drivers\sensors;..\..\Libraries\STM32_CPAL_Driver\devices\stm32f10x;..\..\Libraries\STM32_CPAL_Driver\inc
  library: MicroLIB
  memory RVCT1: ROM 0x8000400 size 0x800
  memory RVCT4: ROM 0x8000000 size 0x400
  memory RVCT5: ROM 0x8000c00 size 0x1f400
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: IoT-Custom.sct
  group Library-CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Library-StdPeriph
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Library-USB-FS
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Library-CPAL
    ../../Libraries/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c cpal_usercallback_template.c
    ../../Libraries/STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
  group Src-usb
    ../usb/src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usbcdc.c usbcommon.c
  group Src-drv
    ../drivers/sensors/: analog.c bh1750.c bmp180.c dht.c mq2.c sr501.c pn532.c pn532HSU.c pn532Reader.c
    ../drivers/actuators/: switch.c irda.c ir.c
    ../drivers/system/: adc.c esp8266.c i2c.c led.c spi.c systick.c usart.c eeprom.c
  group Src-others
    ../: actuators.c common.c iot_node.c main.c retarget.c sensors.c stm32f10x_it.c circular_buffer.c
  group config
    ../config/: pin.h board.h func.h
